# IAR project cm0plus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M0+ Infineon CYT4BF_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group (top)
    ../../: cm0plus.elf
