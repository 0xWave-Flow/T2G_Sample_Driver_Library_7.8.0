<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cm7_1_mc\cm7_1.ewp</path>
    </project>
    <batchBuild />
</workspace>
