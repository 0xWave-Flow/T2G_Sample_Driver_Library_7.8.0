<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cm0plus\cm0plus.ewp</path>
    </project>
    <batchBuild />
</workspace>
