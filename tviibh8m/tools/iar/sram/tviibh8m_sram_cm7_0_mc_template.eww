<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cm7_0_mc\cm7_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
